## boards/shields/saru48wplus/Kconfig.defconfig
```kconfig
if SHIELD_SARU48WPLUS

config ZMK_KEYBOARD_NAME
    default "KeyboardWithRedESC"

endif
```
